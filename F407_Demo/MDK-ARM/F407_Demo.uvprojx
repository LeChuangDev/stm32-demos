# Keil uVision project F407_Demo.uvprojx, settings and files
target Demo (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c include: ..\Drivers\Device\STM32F4xx\Include;..\Drivers\Include;..\Drivers;..\SYSTEM;..\BSP;..\Task;..\Core\Inc;..\Core\Src;..\BSP\Oled_Spi
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Core/: main.c
    ../Drivers/Device/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Core
    ../Core/Src/: encoder.c pwm.c time.c uasrt.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group Bsp
    ../BSP/Oled_Spi/: Oled.c Oled_data.c
    ../BSP/Jy61_P/: Jy61_P.c
