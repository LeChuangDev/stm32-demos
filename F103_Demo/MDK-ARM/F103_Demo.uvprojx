# Keil uVision project F103_Demo.uvprojx, settings and files
target Demo (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\Device\STM32F10x\Include;..\Drivers\Include;..\Drivers;..\SYSTEM;..\Core;..\BSP;..\Task
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Core/: main.c
    ../Drivers/Device/STM32F10x/Source/startup/arm/: startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/: sys.c
