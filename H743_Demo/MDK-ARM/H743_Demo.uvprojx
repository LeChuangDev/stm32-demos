# Keil uVision project H743_Demo.uvprojx, settings and files
target Demo (6230000::V6.23::ARMCLANG)
  device: STM32H743VGHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00080000) IROM2(0x08100000,0x00080000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H743_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H743xx
  c include: ..\Drivers\Device\STM32H7xx\Include;..\Drivers\Include;..\Drivers;..\SYSTEM;..\Core;..\Middlewares;..\BSP;..\Task
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../Core/: mian.c
    ../Drivers/Device/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/: sys.c lib.c uasrt.c
  group Bsp
    ../BSP/Oled_Spi/: Oled.c Oled_data.c
